# Keil uVision project light.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: light +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Library\h;..\User;..\Start
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ../Start/: startup_stm32f10x_hd.s
  group CMSIS
    ../Start/: core_cm3.c system_stm32f10x.c
  group Library
    ../Library/c/: stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_adc.c misc.c stm32f10x_bkp.c
  group User
    ../User/: stm32f10x_it.c main.c bsp_OLED.c bsp_OLED_Data.c bsp_AD_Light.c bsp_PWM.c light_config.c bsp_RTC.c bsp_debug.c hs_ceju.c
